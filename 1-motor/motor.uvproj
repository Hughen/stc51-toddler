# Keil uVision project motor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: motor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c utils.c utils.h key.c key.h lcd.c lcd.h timer0.c timer0.h ds1302.c ds1302.h type.h
